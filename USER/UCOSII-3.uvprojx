# Keil uVision project UCOSII-3.uvprojx, settings and files
target UCOSII-3 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: UCOSII-3 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\FWLIB\inc;..\HARDWARE\TOUCH;..\HARDWARE\BEEP;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\TPAD;..\MALLOC;..\HARDWARE\FWLIB\inc;..\HARDWARE\FATFS\exfuns;..\HARDWARE\FATFS\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../HARDWARE/IIC/: datasheet.txt ucos_task.c include.h
    ./: main.c
    ../UCOSII/CONFIG/: os_cfg.h
  group SYSTEM
    ./: stm32f4xx_it.c system_stm32f4xx.c
    ../CORE/: startup_stm32f40_41xxx.s
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_flash.c stm32f4xx_pwr.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_sdio.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group HARDWARE
    ../HARDWARE/IIC/: flash.c led_fc.c parameter.c spi_nrf.c time.c dma.c
  group COMMUNICATION
    ../HARDWARE/IIC/: nrf.c rc_mine.c rc.c usart_fc.c m100.c
  group CONTROL
    ../HARDWARE/IIC/: height_ctrl.c att_control.c circle.c eso.c
  group MATH&FUSION
    ../HARDWARE/IIC/: fliter.c my_math.c
  group FATA
    ../HARDWARE/FATFS/src/: malloc.c ff.c diskio.c
    ../HARDWARE/FATFS/src/option/: cc936.c
    ../HARDWARE/IIC/: sdio.c sd.c
    ../HARDWARE/FATFS/exfuns/: exfuns.c
